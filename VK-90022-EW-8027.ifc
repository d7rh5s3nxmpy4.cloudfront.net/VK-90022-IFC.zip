Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-06-10T05:26:22
Written by: Processor version 6.0.0.0
Made in: Xbim.IO.MemoryModel

# IfcDistributionPort (8)
Name | FlowDirection
4 x  | SOURCE
4 x  | SINK

# IfcFlowTerminal: VEKTER 15 Street & area lighting luminaires
In: Default Building
Type - Description: - Lamp LED - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour 2700,3000K , 4000K - Die-cast aluminium housing - Pre-treated before powder coating ensuring high corrosion resistance - Single cable entry - One cable gland supplied with 0.5 m of 3x1.0 sqmm outdoor cable - Stainless steel fasteners in grade 304 with zinc flake coating (ZFC) - Durable silicone rubber gasket - Clear toughened glass - High-efficiency PMMA lens - Integral control gear - Maximum wind load resistance is 140 km/h - Surge protection 10kV; PredefinedType: DIRECTIONSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: VK-90022-EW-8027; ModelReference: VEKTER 15 Street & area lighting luminaires; Manufacturer: LIGMAN
Type - Pset_LightFixtureTypeCommon - NumberOfSources: 4; TotalWattage: 19.1 W; LightFixtureMountingType: WallMounted; LightFixturePlacingType: Wall; ManufacturersSpecificInformation: LIGMAN
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: VEKTER, Street and area lighting luminaires; Housing color: Not specified
General Information - Weight: 19.7 kg; Case length: 89.8 cm; Case width: 26 cm; Case height: 34 cm; Uld creation date: 06.10.2026 00:00:00
Mounting Information - Mounting height: 300 cm; Recessed depth: 0 cm
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 100.1 W

# IfcFlowTerminal: VK-90021-EW-8027
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: VK-90021-EW-8027; Light output ratio: 1; Luminous flux: 2507.09 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 2507.09 lm; LightEmitterNominalPower: 19.1 W; Spectrum: 380: 13276, 385: 12437, 390: 12467, 395: 12003, 400: 1282, 405: 11982, 410: 1455, 415: 16641, 420: 20555, 425: 28823, 430: 4074, 435: 60812, 440: 100929, 445: 188435, 450: 239727, 455: 281946, 460: 279709, 465: 257102, 470: 245287, 475: 237889, 480: 2422, 485: 276785, 490: 305752, 495: 324834, 500: 359506, 505: 390434, 510: 412686, 515: 434994, 520: 458121, 525: 475955, 530: 496544, 535: 524201, 540: 51975, 545: 54902, 550: 567027, 555: 590084, 560: 617097, 565: 643734, 570: 680792, 575: 716104, 580: 80952, 585: 810214, 590: 858348, 595: 898566, 600: 936984, 605: 968891, 610: 990601, 615: 999001, 620: 998314, 625: 98602, 630: 961463, 635: 94931, 640: 899367, 645: 860963, 650: 789861, 655: 753894, 660: 681444, 665: 65917, 670: 543419, 675: 528264, 680: 458905, 685: 430593, 690: 397901, 695: 349896, 700: 310156, 705: 270829, 710: 248369, 715: 221123, 720: 16937, 725: 148432, 730: 130004, 735: 110812, 740: 100032, 745: 88651, 750: 80723, 755: 70827, 760: 65915, 765: 58348, 770: 55308, 775: 49467, 780: 0; ColorTemperature: 2700 K; ColorRenderingIndex: 80

# IfcFlowTerminal: VK-90022-EW-8027 (3)
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: VK-90022-EW-8027; Light output ratio: 1; Luminous flux: 2507.09 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 3407.11 lm; LightEmitterNominalPower: 27 W; Spectrum: 380: 13276, 385: 12437, 390: 12467, 395: 12003, 400: 1282, 405: 11982, 410: 1455, 415: 16641, 420: 20555, 425: 28823, 430: 4074, 435: 60812, 440: 100929, 445: 188435, 450: 239727, 455: 281946, 460: 279709, 465: 257102, 470: 245287, 475: 237889, 480: 2422, 485: 276785, 490: 305752, 495: 324834, 500: 359506, 505: 390434, 510: 412686, 515: 434994, 520: 458121, 525: 475955, 530: 496544, 535: 524201, 540: 51975, 545: 54902, 550: 567027, 555: 590084, 560: 617097, 565: 643734, 570: 680792, 575: 716104, 580: 80952, 585: 810214, 590: 858348, 595: 898566, 600: 936984, 605: 968891, 610: 990601, 615: 999001, 620: 998314, 625: 98602, 630: 961463, 635: 94931, 640: 899367, 645: 860963, 650: 789861, 655: 753894, 660: 681444, 665: 65917, 670: 543419, 675: 528264, 680: 458905, 685: 430593, 690: 397901, 695: 349896, 700: 310156, 705: 270829, 710: 248369, 715: 221123, 720: 16937, 725: 148432, 730: 130004, 735: 110812, 740: 100032, 745: 88651, 750: 80723, 755: 70827, 760: 65915, 765: 58348, 770: 55308, 775: 49467, 780: 0; ColorTemperature: 2700 K; ColorRenderingIndex: 80
